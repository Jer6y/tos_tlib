# Keil uVision project 32_TOS.uvprojx, settings and files
target User (6070000::V6.7::.\ARMCLANG)
  device: STM32WLE5JCIx STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") TZ
  output: 32_TOS +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf.exe --text -c -o "$L@L.asm" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,STM32WLE5xx
  c include: ..\APP;..\CONFIG;..\TLIB;..\TLIB_INC;..\TOOLS
  asm include: ..\CONFIG;..\TLIB_INC;..\TOOLS;..\TLIB;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8030000 size 0x10000
  memory RVCT9: RAM 0x20004000 size 0xc000
  memory RVCT10: RAM 0x20003000 size 0x1000
  scatter file: .\stm32wle5xx_flash.sct
  group APP
    ../APP/: app_entry.c tos_shell.h tos_shell_command.h tos_shell.c tos_shell_commands.c tos_kv_flash.h tos_kv.c tos_kv.h tos_kv_err.h
  group CONFIG
    ../CONFIG/: tos_config.h
  group TLIB
    ../tlib/: tlib.h tlib_port.h tlib_s.s
    ../TLIB/: tlib_usr.c
  group TOOLS
    ../TOOLS/: tool.c
  group TLIB_INC
    ../TLIB_INC/: tos_barrier.h tos_binary_heap.h tos_bitmap.h tos_char_fifo.h tos_compiler.h tos_completion.h tos_countdownlatch.h tos_cpu_def.h tos_cpu_types.h tos_event.h tos_k.h tos_kerr.h tos_klib.h tos_ktypes.h tos_list.h tos_mail_queue.h tos_message_queue.h tos_mmblk.h tos_mmheap.h tos_mutex.h tos_pend.h tos_priority_mail_queue.h tos_priority_message_queue.h tos_priority_queue.h tos_ring_queue.h tos_robin.h tos_rwlock.h tos_sched.h tos_sem.h tos_slist.h tos_stopwatch.h tos_sys.h tos_task.h tos_tick.h tos_time.h tos_timer.h
software components: CMSIS:CORE 5.0.1
