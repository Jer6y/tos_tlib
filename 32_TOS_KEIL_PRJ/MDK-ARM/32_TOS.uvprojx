# Keil uVision project 32_TOS.uvprojx, settings and files
target 32_TOS (6070000::V6.7::.\ARMCLANG)
  device: STM32WLE5JCIx STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") TZ
  output: 32_TOS +hex
  AfterMake: fromelf.exe --text -c -o "$L@L.asm" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,STM32WLE5xx
  c include: ../Core/Inc;../Drivers/STM32WLxx_HAL_Driver/Inc;../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../Drivers/CMSIS/Include;..\tos\kernel\include;..\tos\tlib;..\tos\arch
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT5: ROM 0x8030000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x20006000 size 0xa000
  scatter file: stm32wle5xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32wle5xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32wlxx_it.c stm32wlxx_hal_msp.c
    ../APP/: stdio.c
  group Drivers/STM32WLxx_HAL_Driver
    ../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wlxx.c
  group APP
    ../APP/: app_entry.c
  group TLIB
    ../tos/tlib/: tlib.c tlib.h tlib_s.s tlib_usr.c
  group TOS
    ../tos/kernel/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_tlib.c
    ../tos/kernel/include/: tos_barrier.h tos_binary_heap.h tos_bitmap.h tos_char_fifo.h tos_compiler.h tos_completion.h tos_config_check.h tos_config_default.h tos_countdownlatch.h tos_event.h tos_global.h tos_k.h tos_kerr.h tos_klib.h tos_ktypes.h tos_list.h tos_mail_queue.h tos_message_queue.h tos_mmblk.h tos_mmheap.h tos_mutex.h tos_pend.h tos_priority_mail_queue.h tos_priority_message_queue.h tos_priority_queue.h tos_ring_queue.h tos_robin.h tos_rwlock.h tos_sched.h tos_sem.h tos_slist.h tos_stopwatch.h tos_sys.h tos_task.h tos_tick.h tos_time.h tos_timer.h tos_tlib.h tos_version.h
  group ARCH
    ../tos/arch/: port.h port_c.c port_config.h port_s.S tos_cpu.c tos_cpu.h tos_cpu_def.h tos_cpu_types.h tos_fault.c tos_fault.h
  group CONFIG
    ../tos/arch/: tos_config.h
software components: CMSIS:CORE 5.0.1
